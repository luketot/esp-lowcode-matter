## components/sw_timer/Kconfig
```kconfig
menu "Software Timer"
    config MAX_SOFTWARE_TIMERS
    int "Maximum number of timers"
    default 4
endmenu
```
